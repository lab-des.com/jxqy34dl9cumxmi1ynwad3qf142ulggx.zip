Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-10-19T20:43:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 19 20:43:44 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{C381F215-AE2A-4EC9-9A1D-7A355C74F4F0}\ifc * Database version: 5507 * Database creation date: Wed Oct 19 20:43:44 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 19 20:43:44 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 19 20:43:44 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Tabouret Métallique - Japanese red powder-coated, Vitra-Small_Furniture-Tabouret-Metallique:Tabouret Métallique - Japanese red powder-coated:437496
In: Level 1
Type - Material: Japanese red powder-coated (smooth)
Type - Dimensions - NominalDepth: 380 mm; NominalHeight: 445.027 mm; NominalLength: 380 mm
Type - General - Author: BIMstone; BIMObjectName: Vitra-Small_Furniture-Tabouret-Metallique; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 28/09/2022
Type - Identity Data - Cost: 0; Description: The practical stool Tabouret Métallique (1936) by Jean Prouvé, which can also be used as a small side table, exhibits structural affinities with the later Trapèze table.; Designer: Jean Prouvé; Manufacturer: Vitra; Model: Tabouret Métallique - Japanese red powder-coated; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Type Name: Tabouret Métallique - Japanese red powder-coated; URL: https://www.vitra.com/living/product/details/tabouret-metallique
Type - Materials and Finishes - SeatMaterial: Japanese red powder-coated (smooth)
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Japanese red powder-coated; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Small_Furniture-Tabouret-Metallique; Features: n/a; Finish: Material: bent sheet steel, powder-coated finish. Plastic glides.; Grade: n/a; Material: Metal; ModelNumber: n/a; ModelReference: n/a; Name: Tabouret-Metallique; ReplacementCost: n/a; Shape: Sculptured; Size: 380x380x445 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.48262 m2; Volume: 0.0642618 m3
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Vitra-Small_Furniture-Tabouret-Metallique: Tabouret Métallique - Japanese red powder-coated; Family and Type: Vitra-Small_Furniture-Tabouret-Metallique: Tabouret Métallique - Japanese red powder-coated; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Small_Furniture-Tabouret-Metallique: Tabouret Métallique - Japanese red powder-coated; Type Id: Vitra-Small_Furniture-Tabouret-Metallique: Tabouret Métallique - Japanese red powder-coated; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
